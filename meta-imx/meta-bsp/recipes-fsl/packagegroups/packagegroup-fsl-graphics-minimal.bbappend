
DEPENDS_${PN}_append_imx = " \
    packagegroup-fsl-graphics-core \
    packagegroup-fsl-graphics-tools \
    packagegroup-fsl-graphics-demos \
    packagegroup-fsl-graphics-benchmarks \
"
