# Copyright (C) 2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

RDEPENDS_${PN}_remove_mx6sl = " \
    glcompbench \
    "
