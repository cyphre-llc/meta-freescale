
RDEPENDS_${PN}_append_qoriq = "\
    packagegroup-fsl-networking-core-server \
"
