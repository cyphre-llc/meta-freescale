



RDEPENDS_${PN}_qoriq = " \
    valgrind \
"
