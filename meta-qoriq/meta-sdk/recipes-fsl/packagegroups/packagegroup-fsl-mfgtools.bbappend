

RDEPENDS_${PN}_append_e500v2 = " \
    boot-format \
    boot-format-config \
"
