IMAGE_FSTYPES = "tar.gz"
