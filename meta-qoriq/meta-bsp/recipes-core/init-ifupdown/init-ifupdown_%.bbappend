FILESEXTRAPATHS_prepend_qoriq-ppc := "${THISDIR}/${BPN}:"

